* C:\Users\Samyuktha\eSim-Workspace\CaptoDig\CaptoDig22.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 17:53:59

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SC1  Net-_SC1-Pad1_ GND Net-_SC1-Pad3_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_hvt
SC2  Net-_SC2-Pad1_ Net-_SC2-Pad2_ Net-_SC1-Pad1_ Net-_SC1-Pad3_ sky130_fd_pr__pfet_01v8_hvt
SC3  Net-_SC2-Pad1_ Net-_SC2-Pad2_ Net-_SC3-Pad3_ GND sky130_fd_pr__nfet_01v8
SC4  Net-_SC3-Pad3_ Net-_SC4-Pad2_ GND GND sky130_fd_pr__nfet_01v8
U2  Net-_U2-Pad1_ Net-_SC1-Pad3_ Net-_U2-Pad3_ Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ adc_bridge_3
U3  Net-_U1-Pad4_ Net-_SC2-Pad2_ dac_bridge_1
v1  Net-_U2-Pad1_ GND DC
v2  Net-_SC4-Pad2_ GND DC
X1  ip1 Net-_SC2-Pad1_ Net-_X1-Pad3_ VLC_new
X2  Net-_X1-Pad3_ Net-_SC2-Pad1_ Net-_X2-Pad3_ VLC_new
X3  Net-_X2-Pad3_ Net-_SC2-Pad1_ Net-_U2-Pad3_ VLC_new
SC5  Net-_SC2-Pad1_ GND sky130_fd_pr__cap_mim_m3_1
v4  ip1 GND pwl
X4  ip1 Net-_X10-Pad2_ Net-_U7-Pad1_ VLC_new
X5  Net-_U2-Pad3_ Net-_X11-Pad2_ Net-_U7-Pad2_ VLC_new
U5  ip1 Net-_U2-Pad3_ Net-_U5-Pad3_ Net-_U5-Pad4_ adc_bridge_2
X6  Net-_U7-Pad1_ Net-_X10-Pad2_ Net-_U9-Pad1_ VLC_new
X7  Net-_U7-Pad2_ Net-_X11-Pad2_ Net-_U9-Pad2_ VLC_new
U7  Net-_U7-Pad1_ Net-_U7-Pad2_ Net-_U7-Pad3_ Net-_U7-Pad4_ adc_bridge_2
v5  Net-_X10-Pad2_ GND DC
U6  Net-_U6-Pad1_ Net-_U17-Pad8_ dac_bridge_1
U8  Net-_U8-Pad1_ Net-_U17-Pad7_ dac_bridge_1
v6  Net-_X11-Pad2_ GND DC
X8  Net-_U9-Pad1_ Net-_X10-Pad2_ Net-_U11-Pad1_ VLC_new
X9  Net-_U9-Pad2_ Net-_X11-Pad2_ Net-_U11-Pad2_ VLC_new
U9  Net-_U9-Pad1_ Net-_U9-Pad2_ Net-_U9-Pad3_ Net-_U9-Pad4_ adc_bridge_2
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ dac_bridge_1
X10  Net-_U11-Pad1_ Net-_X10-Pad2_ Net-_U13-Pad1_ VLC_new
X11  Net-_U11-Pad2_ Net-_X11-Pad2_ Net-_U13-Pad2_ VLC_new
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ Net-_U11-Pad4_ adc_bridge_2
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ dac_bridge_1
X12  Net-_U13-Pad1_ Net-_X10-Pad2_ Net-_U15-Pad1_ VLC_new
X13  Net-_U13-Pad2_ Net-_X11-Pad2_ Net-_U15-Pad2_ VLC_new
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ Net-_U13-Pad4_ adc_bridge_2
U14  Net-_U14-Pad1_ Net-_U14-Pad2_ dac_bridge_1
X14  Net-_U15-Pad1_ Net-_X10-Pad2_ Net-_U19-Pad1_ VLC_new
X15  Net-_U15-Pad2_ Net-_X11-Pad2_ Net-_U19-Pad2_ VLC_new
U15  Net-_U15-Pad1_ Net-_U15-Pad2_ Net-_U15-Pad3_ Net-_U15-Pad4_ adc_bridge_2
U18  Net-_U18-Pad1_ Net-_U17-Pad3_ dac_bridge_1
X16  Net-_U19-Pad1_ Net-_X10-Pad2_ Net-_U25-Pad1_ VLC_new
X17  Net-_U19-Pad2_ Net-_X11-Pad2_ Net-_U25-Pad2_ VLC_new
U19  Net-_U19-Pad1_ Net-_U19-Pad2_ Net-_U19-Pad3_ Net-_U19-Pad4_ adc_bridge_2
U21  Net-_U21-Pad1_ Net-_U17-Pad2_ dac_bridge_1
U25  Net-_U25-Pad1_ Net-_U25-Pad2_ Net-_U25-Pad3_ Net-_U25-Pad4_ adc_bridge_2
U26  Net-_U26-Pad1_ Net-_U17-Pad1_ dac_bridge_1
U17  Net-_U17-Pad1_ Net-_U17-Pad2_ Net-_U17-Pad3_ Net-_U14-Pad2_ Net-_U12-Pad2_ Net-_U10-Pad2_ Net-_U17-Pad7_ Net-_U17-Pad8_ Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ Net-_U16-Pad4_ Net-_U16-Pad5_ Net-_U16-Pad6_ Net-_U16-Pad7_ Net-_U16-Pad8_ adc_bridge_8
U16  Net-_U16-Pad1_ Net-_U16-Pad2_ Net-_U16-Pad3_ Net-_U16-Pad4_ Net-_U16-Pad5_ Net-_U16-Pad6_ Net-_U16-Pad7_ Net-_U16-Pad8_ Net-_U16-Pad9_ Net-_U16-Pad10_ Net-_U16-Pad11_ samyuktha_encoder
U20  Net-_U16-Pad9_ Net-_U16-Pad10_ Net-_U16-Pad11_ op1 op2 op3 dac_bridge_3
U24  op1 plot_v1
U22  op2 plot_v1
U23  op3 plot_v1
U4  ip1 plot_v1
v3  Net-_SC1-Pad3_ GND DC
scmode1  SKY130mode
X18  Net-_U5-Pad3_ Net-_U5-Pad4_ Net-_U6-Pad1_ Dff1
X19  Net-_U7-Pad3_ Net-_U7-Pad4_ Net-_U8-Pad1_ Dff1
X20  Net-_U9-Pad3_ Net-_U9-Pad4_ Net-_U10-Pad1_ Dff1
X21  Net-_U11-Pad3_ Net-_U11-Pad4_ Net-_U12-Pad1_ Dff1
X22  Net-_U13-Pad3_ Net-_U13-Pad4_ Net-_U14-Pad1_ Dff1
X23  Net-_U15-Pad3_ Net-_U15-Pad4_ Net-_U18-Pad1_ Dff1
X24  Net-_U19-Pad3_ Net-_U19-Pad4_ Net-_U21-Pad1_ Dff1
X25  Net-_U25-Pad3_ Net-_U25-Pad4_ Net-_U26-Pad1_ Dff1
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ sam_mux

.end
